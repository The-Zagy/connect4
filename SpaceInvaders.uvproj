# Keil uVision project SpaceInvaders.uvproj, settings and files
target SpaceInvaders (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SpaceInvaders
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;.\APP;.\HAL\inc;.\HAL\src;.\LIBRARIES\Common;.\LIBRARIES\CpuDriver\inc;.\LIBRARIES\CpuDriver\src;.\MCAL\DIO\inc;.\MCAL\DIO\Src;.\MCAL\INTERRUPT\Inc;.\MCAL\INTERRUPT\Src;.\MCAL\PORT\Inc;.\MCAL\PORT\Src;.\MCAL\SYSTICK\Inc;.\MCAL\SYSTICK\Src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Nokia5110.c random.s SpaceInvaders.c TExaS.c
  group APP
    ./APP/: main.c
  group MCAL
    ./MCAL/DIO/inc/: Dio_Types.h Dio.h
    ./MCAL/INTERRUPT/Inc/: IntCtrl.h IntCtrl_Cfg.h IntCtrl_Types.h
    ./MCAL/INTERRUPT/Src/: IntCtrl_Lcfg.c IntCtrl.c
    ./MCAL/PORT/Inc/: Port_Cfg.h
    ./MCAL/PORT/Src/: Port.c Port_Lcfg.c
    ./MCAL/SYSTICK/Inc/: Systick.h Systick_Types.h
    ./MCAL/SYSTICK/Src/: Systick.c
  group LIBRARIES
    ./LIBRARIES/Common/: Bit_Math.h Compiler.h Mcu_Hw.h Platform_Types.h Std_Types.h
    ./LIBRARIES/CpuDriver/inc/: cpu_driver.h
    ./LIBRARIES/CpuDriver/src/: cpu_driver.c
  group HAL
    ./HAL/inc/: connect4.h
    ./HAL/src/: connect4.c connect4_Lcfg.c ISRs.c
